options:
  parameters:
    author: Muhammad Dzakwan Falih
    copyright: Bityware
    description: Trying transmision over radio with text data
    generate_options: qt_gui
    id: Tx_RX_LINK
    output_language: python
    title: Send Data Over USRP
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/supernode/Project/microwave_experiments/src/USRP_TX_RX/dta_out.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/supernode/Project/microwave_experiments/src/USRP_TX_RX/data.txt
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '500000'
    center_freq0: '915000000'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: '500000'
    center_freq0: '915000000'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '1'
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [digital_gmsk_demod_0, '0', blocks_file_sink_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', digital_gmsk_demod_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
